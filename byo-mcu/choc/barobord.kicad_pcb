# Repository sadekbaroudi/barobord

File README.md:

# Pronunciation

Bar-oh-board

# Support me!

I have spent a lot of time and money designing prototypes, testing, developing, etc. Any contributions would be greatly appreciated!

If you don't want to, or can't afford to support me, please send me a message to let me know you've built one, along with pictures. Also, feel free to submit a pull request with pictures into this repository. I'd be happy to showcase your build.

Reddit: /u/sadekbaroudi
Discord: sadekbaroudi#1258

# Overview

This is a split monoblock keyboard with 40 keys, a 25% typing angle, and other goodies. Feel free to use for personal use, but any selling or reselling of this is prohibited without explicit consent.

There are three versions of this board. I have personally fabricated and tested the mx and the choc versions. I have not tested the byo-mcu version, but it's the same wiring as the mx version (and much simpler). It should work fine.

See the build guide, descriptions of the three versions, and BOM for all three here:
https://github.com/sadekbaroudi/barobord/blob/master/BUILDGUIDE.md

# Do you want to test the layout?

Print the file below on a sheet of paper. Test it out!

[Layout tester](layout-tester.pdf)

# Firmware

barobord supports [vial](https://get.vial.today/)! Download it, build and flash the firmware, and vial will allow you to configure it. If you don't want to learn how to flash firmware, I have prebuilt some that you can find here:
[Prepared firmware](https://github.com/sadekbaroudi/barobord/tree/master/firmware)

If you want to build the firmware yourself, you can access it here for the integrated atmega32u4 version:
[Barobord QMK firmware](https://github.com/sadekbaroudi/vial-qmk/tree/vial/keyboards/fingerpunch/barobord)

Or here for the byo-mcu version:
[Barobord byo-mcu QMK firmware](https://github.com/sadekbaroudi/vial-qmk/tree/vial/keyboards/fingerpunch/barobord_byomcu)

# Images

## v1-mx

## v1-choc

## Prototype

## KiCad design byo-mcu/choc/barobord.kicad_pcb

Parts:
Brd1: SSD1306; 128x64OLED
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D81, D82: 1N4148W; D_SOD-123; LCSC C727110
D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80: SK6812MINI-E; MX_SK6812MINI-E
J1: Pimoroni; pimoroni
J2: Conn_01x03_Female; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal; LCSC C157929
R4: 10k; R_0805_2012Metric; LCSC C17414
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40: SW_Push; Kailh_socket_PG1350
SW41: SW_Push; SKQG-1155865
SW42, SW43: RotaryEncoder_Switch; RotaryEncoder_EC11-no-legs
SW44, SW45: EVQWGD001
SW46: SW_DIP_x01; SW_CuK_OS102011MA1QN1_SPDT_Angled
U1: Elite-C
U2: nice_nano

Connections:
+5V: Brd1.2 (VCC), D41.1 (VDD), D42.1 (VDD), D43.1 (VDD), D44.1 (VDD), D45.1 (VDD), D46.1 (VDD), D47.1 (VDD), D48.1 (VDD), D49.1 (VDD), D50.1 (VDD), D51.1 (VDD), D52.1 (VDD), D53.1 (VDD), D54.1 (VDD), D55.1 (VDD), D56.1 (VDD), D57.1 (VDD), D58.1 (VDD), D59.1 (VDD), D60.1 (VDD), D61.1 (VDD), D62.1 (VDD), D63.1 (VDD), D64.1 (VDD), D65.1 (VDD), D66.1 (VDD), D67.1 (VDD), D68.1 (VDD), D69.1 (VDD), D70.1 (VDD), D71.1 (VDD), D72.1 (VDD), D73.1 (VDD), D74.1 (VDD), D75.1 (VDD), D76.1 (VDD), D77.1 (VDD), D78.1 (VDD), D79.1 (VDD), D80.1 (VDD), J1.1, R4.1, U1.21 (VCC), U2.21 (VCC)
B+: SW46.1, U1.24 (B0), U2.24 (BATIN/P0.04)
B-: J2.1, J2.3, U1.23 (GND), U2.23 (GND)
ENC1A: SW42.A, SW44.A, U1.26 (D5), U2.32 (P1.02)
ENC1B: SW42.B, SW44.B, U1.25 (B7), U2.31 (P1.01)
ENC2A: SW43.A, SW45.A, U1.15 (14/PB3), U2.15 (P1.11)
ENC2B: SW43.B, SW45.B, U1.27 (C7), U2.33 (P1.07)
GND: Brd1.1 (GND), D41.3 (VSS), D42.3 (VSS), D43.3 (VSS), D44.3 (VSS), D45.3 (VSS), D46.3 (VSS), D47.3 (VSS), D48.3 (VSS), D49.3 (VSS), D50.3 (VSS), D51.3 (VSS), D52.3 (VSS), D53.3 (VSS), D54.3 (VSS), D55.3 (VSS), D56.3 (VSS), D57.3 (VSS), D58.3 (VSS), D59.3 (VSS), D60.3 (VSS), D61.3 (VSS), D62.3 (VSS), D63.3 (VSS), D64.3 (VSS), D65.3 (VSS), D66.3 (VSS), D67.3 (VSS), D68.3 (VSS), D69.3 (VSS), D70.3 (VSS), D71.3 (VSS), D72.3 (VSS), D73.3 (VSS), D74.3 (VSS), D75.3 (VSS), D76.3 (VSS), D77.3 (VSS), D78.3 (VSS), D79.3 (VSS), D80.3 (VSS), J1.5, SW41.1, SW42.C, SW43.C, SW44.C, SW45.C, U1.3 (GND), U1.4 (GND), U2.3 (GND), U2.4 (GND)
unnamed: D1.2 (A), SW1.1
unnamed: D2.2 (A), SW2.1
unnamed: D3.2 (A), SW3.1
unnamed: D4.2 (A), SW4.1
unnamed: D5.2 (A), SW5.1
unnamed: D6.2 (A), SW6.1
unnamed: D7.2 (A), SW7.1
unnamed: D8.2 (A), SW8.1
unnamed: D9.2 (A), SW9.1
unnamed: D10.2 (A), SW10.1
unnamed: D11.2 (A), SW11.1
unnamed: D12.2 (A), SW12.1
unnamed: D13.2 (A), SW13.1
unnamed: D14.2 (A), SW14.1
unnamed: D15.2 (A), SW15.1
unnamed: D16.2 (A), SW16.1
unnamed: D17.2 (A), SW17.1
unnamed: D18.2 (A), SW18.1
unnamed: D19.2 (A), SW19.1
unnamed: D20.2 (A), SW20.1
unnamed: D21.2 (A), SW21.1
unnamed: D22.2 (A), SW22.1
unnamed: D23.2 (A), SW23.1
unnamed: D24.2 (A), SW24.1
unnamed: D25.2 (A), SW25.1
unnamed: D26.2 (A), SW26.1
unnamed: D27.2 (A), SW27.1
unnamed: D28.2 (A), SW28.1
unnamed: D29.2 (A), SW29.1
unnamed: D30.2 (A), SW30.1
unnamed: D31.2 (A), SW31.1
unnamed: D32.2 (A), SW32.1
unnamed: D33.2 (A), SW33.1
unnamed: D34.2 (A), SW34.1
unnamed: D35.2 (A), SW35.1
unnamed: D36.2 (A), SW36.1
unnamed: D37.2 (A), SW37.1
unnamed: D38.2 (A), SW38.1
unnamed: D39.2 (A), SW39.1
unnamed: D40.2 (A), SW40.1
unnamed: D41.2 (DOUT), D42.4 (DIN)
unnamed: D42.2 (DOUT), D43.4 (DIN)
unnamed: D43.2 (DOUT), D44.4 (DIN)
unnamed: D44.2 (DOUT), D45.4 (DIN)
unnamed: D45.2 (DOUT), D46.4 (DIN)
unnamed: D46.2 (DOUT), D47.4 (DIN)
unnamed: D47.2 (DOUT), D48.4 (DIN)
unnamed: D48.2 (DOUT), D49.4 (DIN)
unnamed: D49.2 (DOUT), D50.4 (DIN)
unnamed: D50.2 (DOUT), D51.4 (DIN)
unnamed: D51.2 (DOUT), D52.4 (DIN)
unnamed: D52.2 (DOUT), D53.4 (DIN)
unnamed: D53.2 (DOUT), D54.4 (DIN)
unnamed: D54.2 (DOUT), D55.4 (DIN)
unnamed: D55.2 (DOUT), D56.4 (DIN)
unnamed: D56.2 (DOUT), D57.4 (DIN)
unnamed: D57.2 (DOUT), D58.4 (DIN)
unnamed: D58.2 (DOUT), D59.4 (DIN)
unnamed: D59.2 (DOUT), D60.4 (DIN)
unnamed: D60.2 (DOUT), D61.4 (DIN)
unnamed: D61.2 (DOUT), D62.4 (DIN)
unnamed: D62.2 (DOUT), D63.4 (DIN)
unnamed: D63.2 (DOUT), D64.4 (DIN)
unnamed: D64.2 (DOUT), D65.4 (DIN)
unnamed: D65.2 (DOUT), D66.4 (DIN)
unnamed: D66.2 (DOUT), D67.4 (DIN)
unnamed: D67.2 (DOUT), D68.4 (DIN)
unnamed: D68.2 (DOUT), D69.4 (DIN)
unnamed: D69.2 (DOUT), D70.4 (DIN)
unnamed: D70.2 (DOUT), D71.4 (DIN)
unnamed: D71.2 (DOUT), D72.4 (DIN)
unnamed: D72.2 (DOUT), D73.4 (DIN)
unnamed: D73.2 (DOUT), D74.4 (DIN)
unnamed: D74.2 (DOUT), D75.4 (DIN)
unnamed: D75.2 (DOUT), D76.4 (DIN)
unnamed: D76.2 (DOUT), D77.4 (DIN)
unnamed: D77.2 (DOUT), D78.4 (DIN)
unnamed: D78.2 (DOUT), D79.4 (DIN)
unnamed: D79.2 (DOUT), D80.4 (DIN)
unnamed: D81.2 (A), SW42.S2, SW44.S2
unnamed: D82.2 (A), SW43.S2, SW45.S2
unnamed: J2.2, SW46.2
RESET: R4.2, SW41.2, U1.22 (RST), U2.22 (RST)
col0: SW1.2, SW11.2, SW21.2, SW31.2, U1.2 (RX1/PD2), U2.2 (RX1/P0.08)
col1: SW2.2, SW12.2, SW22.2, SW32.2, U1.7 (4/PD4), U2.7 (P0.22)
col2: SW3.2, SW13.2, SW23.2, SW33.2, U1.8 (5/PC6), U2.8 (P0.24)
col3: SW4.2, SW14.2, SW24.2, SW34.2, SW43.S1, SW45.S1, U1.9 (6/PD7), U2.9 (P1.00)
col4: SW5.2, SW15.2, SW25.2, SW35.2, SW42.S1, SW44.S1, U1.10 (7/PE6), U2.10 (P0.11)
col5: SW6.2, SW10.2, SW16.2, SW26.2, SW36.2, U1.19 (A2/PF5), U2.19 (AIN5/P0.29)
col6: SW7.2, SW17.2, SW20.2, SW27.2, SW37.2, U1.18 (A1/PF6), U2.18 (AIN0/P0.02)
col7: SW8.2, SW18.2, SW28.2, SW30.2, SW38.2, U1.17 (A0/PF7), U2.17 (P1.15)
col8: SW9.2, SW19.2, SW29.2, SW39.2, SW40.2, U1.16 (15/PB1), U2.16 (P1.13)
led: D41.4 (DIN), U1.1 (TX0/PD3), U2.1 (TX0/P0.06)
row0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), U1.13 (10/PB6), U2.13 (NFC1/P0.09)
row1: D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), U1.20 (A3/PF4), U2.20 (AIN7/P0.31)
row2: D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), U1.12 (9/PB5), U2.12 (P1.06)
row3: D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), U1.11 (8/PB4), U2.11 (P1.04)
row4: D10.1 (K), D20.1 (K), D30.1 (K), D40.1 (K), D81.1 (K), D82.1 (K), U1.14 (16/PB2), U2.14 (NFC2/P0.10)
scl: Brd1.3 (SCL), J1.3, U1.6 (3/PD0), U2.6 (P0.20)
sda: Brd1.4 (SDA), J1.2, U1.5 (2/PD1), U2.5 (P0.17)

Board: 2 copper layers, 243.2 x 136.2 mm, 134 parts (47 on the bottom side), 108 nets.

File byo-mcu/choc/gerbers/barobord-bom.csv:

Comment,Designator,Footprint,LCSC
"SSD1306","Brd1","SSD1306:128x64OLED",""
"1N4148W","D1,D2,D3,D4,D5,D6,D7,D8,D9,D10,D11,D12,D13,D14,D15,D16,D17,D18,D19,D20,D21,D22,D23,D24,D25,D26,D27,D28,D29,D30,D31,D32,D33,D34,D35,D36,D37,D38,D39,D40,D81,D82","Diode_SMD:D_SOD-123","C727110"
"SK6812MINI-E","D41,D42,D43,D44,D45,D46,D47,D48,D49,D50,D51,D52,D53,D54,D55,D56,D57,D58,D59,D60,D61,D62,D63,D64,D65,D66,D67,D68,D69,D70,D71,D72,D73,D74,D75,D76,D77,D78,D79,D80","kicad-keyboard-parts:MX_SK6812MINI-E",""
"Pimoroni","J1","other_parts:pimoroni",""
"Conn_01x03_Female","J2","Connector_JST:JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal","C157929"
"10k","R4","Resistor_SMD:R_0805_2012Metric","C17414"
"SW_Push","SW1,SW2,SW3,SW4,SW5,SW6,SW7,SW8,SW9,SW10,SW11,SW12,SW13,SW14,SW15,SW16,SW17,SW18,SW19,SW20,SW21,SW22,SW23,SW24,SW25,SW26,SW27,SW28,SW29,SW30,SW31,SW32,SW33,SW34,SW35,SW36,SW37,SW38,SW39,SW40","keyswitches:Kailh_socket_PG1350",""
"SW_Push","SW41","random-keyboard-parts:SKQG-1155865",""
"RotaryEncoder_Switch","SW42,SW43","Keebio-Parts:RotaryEncoder_EC11-no-legs",""
"EVQWGD001","SW44,SW45","other_parts:EVQWGD001",""
"SW_DIP_x01","SW46","Button_Switch_THT:SW_CuK_OS102011MA1QN1_SPDT_Angled",""
"Elite-C","U1","Keebio-Parts:Elite-C",""
"nice_nano","U2","Keebio-Parts:nice_nano",""

## Commit log

2021-07-15 first commit, schematic complete, still need to wire everything
2021-07-15 first phase of wiring complete - mcu, usb, and rows and columns
2021-07-16 wiring and layout complete, will still add some cool stuff in the middle
2021-07-16 few fixes to the schematic and wiring
2021-07-16 added logo and gerbers
2021-07-17 added pimoroni trackball support, updated logo
2021-07-17 Added two rotary encoders
2021-07-17 Added OLED support, must pick either OLED or pimoroni, as they both use SDA SCL
2021-07-17 Forgot to add column 10 for rotary encoder switches
2021-07-18 Added support for the EVQWGD001 rotary encoders
2021-07-18 Updated gerbers
2021-07-25 added choc board, updated mx board to have reversed switch footprints for LEDs on top
2021-07-25 moved base directory to mx directory
2021-07-25 messed up readmes
2021-07-30 added plate svgs and dxfs, OLED logo, and some notes for future changes
2021-07-30 added 3d models for plate case as well
2021-08-01 added better case
2021-08-02 added new negatively sloped case
2021-08-06 updated encoders to be a little higher, don't think I'm going to use this, but committing just in case
2021-08-06 updating and adding cases
2021-08-08 updated choc plates and added pimoroni OLED and encoder covers
2021-08-08 updated bottom plate
2021-08-09 get choc ready for fabrication
2021-08-10 Updated covers STLs to be better fit the spacing
2021-08-28 updated images, cases, and readmes
2021-08-28 removing choc bottom plate gerbers directory
2021-09-01 added paypal donation link
2021-09-01 added feature todo list
2021-09-03 added an MCU agnostic pcb
2021-09-03 added new image for readme
2021-09-03 updated todos
2021-09-03 removed the version where I moved the encoders
2021-09-03 added byo-mcu gerbers
2021-09-03 updated mcu footprint to show pinout for both nice nano and elite-c
2021-09-03 Adding build guide
2021-09-03 Updated readme with more description and link to build guide
2021-09-03 added verbiage to ask people to share builds and pictures with me
2021-09-03 Mistake in build guide for choc
2021-09-04 added a second build image for choc
2021-09-09 todo update
2021-09-09 added underglow support for the MX version (not byo-mcu or choc)
2021-09-09 added rounded corners to covers, and added support for one more cover type
2021-09-09 added 36 key switchplate case for elisiano
2021-09-10 added printable layout tester
2021-09-17 updated readme with link to firmware
2021-09-18 added gerbers for plates that support any barobord
2021-09-18 updated kicad files according to the previous commit's gerbers
2021-09-18 moved outside plates to either directory
2021-09-18 added gerber zips
2021-09-18 updated build guide per the new plates for outside pcb
2021-11-11 updated README.md with warning for byo-mcu version until I fix the issue
2021-11-13 updated byo-mcu to work
2021-11-15 added firmware and instructions
2021-11-15 updated readme to clarify the firmware situation for the byo-mcu version
2021-11-15 added true vial support
2021-11-15 added vial example
2021-11-15 updated firmware with better default configuration
2021-11-16 added rgb controls as well
2021-11-21 updated without TAPPING_FORCE_HOLD enabled
2021-11-21 added support for casemodes in vial builds for barobord
2021-11-21 added docs for user functions in firmware readme
2021-11-22 added my personal layout to the repo
2021-11-30 updated paypal link to direct paypal instead of donation, since they take 29%
2021-12-09 added mounting holes for byo-mcu, and moved the on off switch to the top of the board
2021-12-10 added byo-mcu choc version for Apsu
2021-12-17 updated readmes to be more precise
2021-12-17 converted jst connector from 2 pin to 3 pin to help prevent people from plugging in the battery backwards, and to support both wiring configurations for batteries
2021-12-31 added bottom plate 3d printable files
2022-01-08 added byo-mcu support for firmware
2022-01-13 updated firmware and links to fingerpunch
2022-02-06 forgot to update readme to note that there is firmware that supports byo-mcu now
2022-02-06 updated a bit more clarity on low profile board screw types
2022-02-24 added high profile case
2024-04-05 added cirque support for barobord high profile case
